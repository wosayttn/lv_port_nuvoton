# Keil uVision project lvgl.uvprojx, settings and files
target Caffee_Machine_LCD5_V1_2 (6240000::V6.24::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.4-rc.3
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: lvgl_caffee_machine_lcd5_v1_2
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=4 wLevel=3
  c define: __800x480__ LV_CONF_INCLUDE_SIMPLE NVT_DCACHE_ON SLS_CAFFEE_MACHINE=1 __FREERTOS__=1 CONFIG_DISP_LT7381=1 CONFIG_DISP_LINE_BUFFER_NUMBER=DISP_VER_RES_MAX/2
  c misc: -include ../ffconf.h
  c include: ..\;..\..\..\board\numaker-x-m55m1d\plat_driver\spim_hyperram;..\..\..\board\numaker-x-m55m1d\plat_driver\gdma;..\..\..\board\numaker-x-m55m1d\plat_driver\;..\..\..\board\numaker-x-m55m1d;..\..\..\bsp\m55m1\Library\CMSIS\DSP\Include;..\..\..\bsp\M55M1\Library\CMSIS\Core\Include;..\..\..\bsp\M55M1\Library\Device\Nuvoton\M55M1\Include;..\..\..\bsp\M55M1\Library\StdDriver\inc;..\..\..\common\drv_disp;..\..\..\common\drv_indev;..\..\..\common;..\..\..\lvgl\src;..\..\..\lvgl\src\core;..\..\..\lvgl\src\draw;..\..\..\lvgl\src\draw\sw;..\..\..\lvgl\src\font;..\..\..\lvgl\src\misc;..\..\..\lvgl\src\widgets;..\..\..\lvgl\demos\;..\..\..\lvgl\demos\benchmark;..\..\..\lvgl\demos\music;..\..\..\lvgl\demos\stress;..\..\..\lvgl\demos\widgets;..\..\..\lvgl\demos\music\assets;..\..\..\lvgl\demos\keypad_encoder;..\..\..\thirdparty\FatFs\source;..\..\..\thirdparty\FreeRTOS\portable\GCC\ARM_CM55_NTZ\non_secure;..\..\..\bsp\m55m1\Library\CMSIS\DSP\Include;..\..\..\thirdparty\arm2d\Library\Include;..\..\..\thirdparty\FreeRTOS\include;..\..\..\
  asm define: M55M1
  asm include: ..\
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\M55M1.scatter
  group src
    ../: main.c
    ../../../board/numaker-x-m55m1d/components/: task_lv.c
  group libraries
    ../../../bsp/m55m1/Library/StdDriver/src/: clk.c ebi.c gpio.c pdma.c retarget.c sys.c uart.c i2c.c spim.c spim_hyper.c sdh.c crc.c
    ../../../bsp/m55m1/Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
    ../../../board/numaker-x-m55m1d/plat_driver/spim_hyperram/: hyperram_code.c
    ../../../board/numaker-x-m55m1d/plat_driver/gdma/: dma350_ch_drv.c dma350_drv.c dma350_lib.c
    ../../../board/numaker-x-m55m1d/plat_driver/spim_norflash/: norflash_code.c cmdcode.c
  group lvgl
    ../../../lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_observer.c lv_refr.c
    ../../../lvgl/src/debugging/monkey/: lv_monkey.c
    ../../../lvgl/src/debugging/profiler/: lv_profiler_builtin.c lv_profiler_builtin_posix.c
    ../../../lvgl/src/debugging/sysmon/: lv_sysmon.c
    ../../../lvgl/src/debugging/vg_lite_tvg/: vg_lite_matrix.c
    ../../../lvgl/src/display/: lv_display.c
    ../../../lvgl/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    ../../../lvgl/src/draw/convert/: lv_draw_buf_convert.c
    ../../../lvgl/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    ../../../lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_utils.c lv_draw_vector.c
    ../../../lvgl/src/draw/snapshot/: lv_snapshot.c
    ../../../lvgl/src/draw/sw/blend/arm2d/: lv_blend_arm2d.c
    ../../../lvgl/src/draw/sw/blend/helium/: lv_blend_helium.S
    ../../../lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../../../lvgl/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    ../../../lvgl/src/draw/sw/blend/riscv_v/: lv_draw_sw_blend_riscv_v_to_rgb888.c
    ../../../lvgl/src/draw/sw/blend/sve2/: lv_draw_sw_blend_sve2_to_rgb888.c
    ../../../lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c
    ../../../lvgl/src/font/binfont_loader/: lv_binfont_loader.c
    ../../../lvgl/src/font/fmt_txt/: lv_font_fmt_txt.c
    ../../../lvgl/src/font/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../../../lvgl/src/font/imgfont/: lv_imgfont.c
    ../../../lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../../../lvgl/src/fs/: lv_fs.c lv_fs_fatfs.c lv_fs_frogfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
    ../../../lvgl/src/image/: lv_bin_decoder.c lv_bmp.c lv_image_decoder.c lv_libjpeg_turbo.c lv_libpng.c lv_libwebp.c lv_lodepng.c lv_tjpgd.c
    ../../../lvgl/src/indev/: lv_gridnav.c lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../../../lvgl/src/layouts/flex/: lv_flex.c
    ../../../lvgl/src/layouts/grid/: lv_grid.c
    ../../../lvgl/src/layouts/: lv_layout.c
    ../../../lvgl/src/libs/gif/: gif.c
    ../../../lvgl/src/libs/lodepng/: lodepng.c
    ../../../lvgl/src/libs/lz4/: lz4.c
    ../../../lvgl/src/libs/nanovg/: nanovg.c
    ../../../lvgl/src/libs/tjpgd/: tjpgd.c
    ../../../lvgl/src/logging/: lv_log.c
    ../../../lvgl/src/: lv_init.c
    ../../../lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../../../lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../../../lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../../../lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_bidi_common.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_grad.c lv_iter.c lv_ll.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../../../lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
    ../../../lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../../../lvgl/src/others/translation/: lv_translation.c
    ../../../lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../../../lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../../../lvgl/src/stdlib/: lv_mem.c
    ../../../lvgl/src/themes/default/: lv_theme_default.c
    ../../../lvgl/src/themes/: lv_theme.c
    ../../../lvgl/src/themes/mono/: lv_theme_mono.c
    ../../../lvgl/src/themes/simple/: lv_theme_simple.c
    ../../../lvgl/src/tick/: lv_tick.c
    ../../../lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ../../../lvgl/src/widgets/animimage/: lv_animimage.c
    ../../../lvgl/src/widgets/arc/: lv_arc.c
    ../../../lvgl/src/widgets/arclabel/: lv_arclabel.c
    ../../../lvgl/src/widgets/bar/: lv_bar.c
    ../../../lvgl/src/widgets/button/: lv_button.c
    ../../../lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../../../lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../../lvgl/src/widgets/canvas/: lv_canvas.c
    ../../../lvgl/src/widgets/chart/: lv_chart.c
    ../../../lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../../../lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../../../lvgl/src/widgets/gif/: lv_gif.c
    ../../../lvgl/src/widgets/image/: lv_image.c
    ../../../lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../../../lvgl/src/widgets/ime/: lv_ime_pinyin.c
    ../../../lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../../../lvgl/src/widgets/label/: lv_label.c
    ../../../lvgl/src/widgets/led/: lv_led.c
    ../../../lvgl/src/widgets/line/: lv_line.c
    ../../../lvgl/src/widgets/list/: lv_list.c
    ../../../lvgl/src/widgets/lottie/: lv_lottie.c
    ../../../lvgl/src/widgets/menu/: lv_menu.c
    ../../../lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../../../lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../../../lvgl/src/widgets/property/: lv_animimage_properties.c lv_arc_properties.c lv_bar_properties.c lv_buttonmatrix_properties.c lv_chart_properties.c lv_checkbox_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_led_properties.c lv_line_properties.c lv_menu_properties.c lv_obj_properties.c lv_roller_properties.c lv_scale_properties.c lv_slider_properties.c lv_span_properties.c lv_spinbox_properties.c lv_spinner_properties.c lv_style_properties.c lv_switch_properties.c lv_table_properties.c lv_tabview_properties.c lv_textarea_properties.c
    ../../../lvgl/src/widgets/roller/: lv_roller.c
    ../../../lvgl/src/widgets/scale/: lv_scale.c
    ../../../lvgl/src/widgets/slider/: lv_slider.c
    ../../../lvgl/src/widgets/span/: lv_span.c
    ../../../lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../../../lvgl/src/widgets/spinner/: lv_spinner.c
    ../../../lvgl/src/widgets/switch/: lv_switch.c
    ../../../lvgl/src/widgets/table/: lv_table.c
    ../../../lvgl/src/widgets/tabview/: lv_tabview.c
    ../../../lvgl/src/widgets/textarea/: lv_textarea.c
    ../../../lvgl/src/widgets/tileview/: lv_tileview.c
    ../../../lvgl/src/widgets/win/: lv_win.c
  group plat_driver
    ../../../board/numaker-x-m55m1d/plat_driver/: diskio.c sdreader.c drv_pdma.c touch_glue.c disp_glue.c
    ../../../common/: lv_port_disp.c lv_port_indev.c nu_misc.c
    ../: lv_conf.h
    ../../../common/drv_indev/: plat_touch.c
  group LCD5_V1_2
    ../../../common/drv_disp/: lt7381_ebi.c disp_lt7381.c
    ../../../common/drv_indev/: touch_ft5316.c
  group LCD43_V1_0
    ../../../common/drv_indev/: touch_st1663i.c
    ../../../common/drv_disp/: disp_fsa506.c fsa506_ebi.c
  group LCD43_V1_1
    ../../../common/drv_disp/: disp_nv3041a.c nv3041a_ebi.c
    ../../../common/drv_indev/: touch_gt911.c
  group DISP_EBI_SYNC
    ../../../common/drv_disp/: disp_ebi_sync_gdma.c disp_ebi_sync.c
    ../../../board/numaker-x-m55m1d/plat_driver/: lv_port_disp_sync.c
  group FreeRTOS
    ../../../common/: multithread.c
    ../../../thirdparty/FreeRTOS/: list.c queue.c tasks.c timers.c
    ../../../thirdparty/FreeRTOS/portable/MemMang/: heap_3.c
    ../../../thirdparty/FreeRTOS/portable/GCC/ARM_CM55_NTZ/non_secure/: port.c portasm.c
  group lv_draw
    ../../../common/drv_draw/gdma/: drv_gdma.c lv_draw_gdma.c lv_draw_gdma_fill.c lv_draw_gdma_image.c lv_draw_gdma_layer.c
  group fatfs
    ../../../thirdparty/FatFs/source/: ff.c ffsystem.c ffunicode.c
  group arm2d
    ../../../thirdparty/arm2d/Library/Source/: arm_2d.c arm_2d_alpha_blending.c arm_2d_async.c arm_2d_conversion.c arm_2d_draw.c arm_2d_filter.c arm_2d_helium.c arm_2d_transform.c __arm_2d_tile.c __arm_2d_tile_2xssaa_transform.c __arm_2d_tile_4xssaa_transform_src_mask_helium.c __arm_2d_tile_copy_with_source_mask_and_opacity.c __arm_2d_tile_copy_with_source_mask_and_opacity_helium.c __arm_2d_transform_helium.c
    ../../../bsp/m55m1/Library/CMSIS/DSP/Source/FastMathFunctions/: arm_cos_f32.c arm_cos_q31.c arm_sin_f32.c arm_sin_q31.c
    ../../../bsp/m55m1/Library/CMSIS/DSP/Source/CommonTables/: arm_common_tables.c
  group sls_caffee_machine
    ../sls_files_caffee_machine/: ui.c ui_helpers.c ui_theme_manager.c ui_themes.c
    ../sls_files_caffee_machine/screens/: ui_Screen_Add_coffee.c ui_Screen_Add_water.c ui_Screen_Brewing.c ui_Screen_Brewing_Done.c ui_Screen_Customize.c ui_Screen_Customize2.c ui_Screen_Home.c ui_Screen_Home_espresso.c ui_Screen_Home_ristretto.c ui_Screen_Ready.c ui_Screen_Settings.c ui_Screen_Splash_screen.c
    ../sls_files_caffee_machine/images/: ui_img_266850372.c ui_img_1726788397.c ui_img_alert_png.c ui_img_arrow_png.c ui_img_arrows_png.c ui_img_beans_white_png.c ui_img_bg_png.c ui_img_big_espresso_png.c ui_img_big_latte_png.c ui_img_big_ristretto_png.c ui_img_bigbean_png.c ui_img_ble_png.c ui_img_chevron_png.c ui_img_clean_png.c ui_img_coffee_illustration_png.c ui_img_cup_png.c ui_img_cup1_png.c ui_img_cups_png.c ui_img_disabledbean_png.c ui_img_done_60_png.c ui_img_done_png.c ui_img_espresso_png.c ui_img_foam_body_png.c ui_img_foam_png.c ui_img_languages_png.c ui_img_latte_illustration_png.c ui_img_light_png.c ui_img_parameters_png.c ui_img_play_button_png.c ui_img_profile_png.c ui_img_roller_png.c ui_img_settings_png.c ui_img_shape1_png.c ui_img_slider_bg_png.c ui_img_standby_png.c ui_img_tank_png.c ui_img_taste1_png.c ui_img_temp_body_png.c ui_img_temperature_png.c ui_img_top_png.c ui_img_units_png.c ui_img_water_png.c ui_img_wave_bottom_png.c ui_img_wave1_png.c ui_img_wifi_png.c
    ../sls_files_caffee_machine/fonts/: ui_font_badge2.c ui_font_exclamation.c ui_font_H1_bold.c ui_font_H2_bold.c ui_font_H3_bold.c ui_font_icon.c ui_font_Min.c ui_font_P1_bold.c ui_font_P1_medium.c ui_font_P2_medium.c
    ../sls_files_caffee_machine/components/: ui_comp.c ui_comp_button.c ui_comp_cta_container.c ui_comp_header.c ui_comp_home_sliders.c ui_comp_homeslider.c ui_comp_hook.c ui_comp_parameter.c ui_comp_progress.c ui_comp_ready_button.c ui_comp_selector.c ui_comp_separator.c ui_comp_slider1.c ui_comp_slider3.c ui_comp_steps.c
  group sls_ebike_480x272
    ../sls_files_ebike_480x272/: ui.c ui_helpers.c
    ../sls_files_ebike_480x272/screens/: ui_Home.c ui_Settings.c
    ../sls_files_ebike_480x272/images/: ui_img_battery_bg_png.c ui_img_ebike_bg_png.c ui_img_gps_bg_png.c ui_img_gps_knob_png.c ui_img_icn_battery_png.c ui_img_icn_bike_png.c ui_img_icn_charge_png.c ui_img_icn_flash_png.c ui_img_icn_map_png.c ui_img_icn_ok_png.c ui_img_icn_settings_png.c ui_img_icn_x_png.c ui_img_icn_x2_png.c ui_img_map_png.c ui_img_menu_line_png.c ui_img_menu_on_png.c ui_img_particle_1_png.c ui_img_particle_2_png.c ui_img_particle_3_png.c ui_img_pin_line_png.c ui_img_pin_on_png.c ui_img_right_png.c ui_img_settings_bg_png.c ui_img_settings_corner_png.c ui_img_slider_battery_png.c ui_img_speed_slider_png.c ui_img_volume_off_png.c ui_img_volume_on_png.c ui_img_water_1_png.c ui_img_water_2_png.c
    ../sls_files_ebike_480x272/fonts/: ui_font_Big.c ui_font_Medium.c ui_font_Number.c ui_font_Small.c
    ../sls_files_ebike_480x272/components/: ui_comp.c ui_comp_dropdown.c ui_comp_hook.c ui_comp_roller.c
  group sls_3d_printer
    ../sls_files_3d_printer/: ui.c ui_helpers.c
    ../sls_files_3d_printer/screens/: ui_Screen_1_Print.c ui_Screen_2_Move.c ui_Screen_3_Setting.c
    ../sls_files_3d_printer/images/: ui_img_3d_printer_bg_png.c ui_img_arrow_down_png.c ui_img_arrow_left_png.c ui_img_arrow_right_png.c ui_img_arrow_up_png.c ui_img_btn_main_off_png.c ui_img_btn_main_on_png.c ui_img_btn_move_png.c ui_img_btn_pad_bottom_png.c ui_img_btn_pad_top_png.c ui_img_btn_print_down_png.c ui_img_btn_print_png.c ui_img_btn_print_top_off_png.c ui_img_btn_setting_png.c ui_img_btn_z_botton_png.c ui_img_btn_z_top_png.c ui_img_icn_bed_png.c ui_img_icn_head_png.c ui_img_icn_pause_png.c ui_img_icn_pc_png.c ui_img_icn_stop_png.c ui_img_icn_time_1_png.c ui_img_icn_time_2_png.c ui_img_icn_usb_png.c ui_img_icn_wifi_png.c ui_img_print_view_bg_png.c ui_img_print_view_front_png.c ui_img_roller_bg_png.c
    ../sls_files_3d_printer/fonts/: ui_font_Small_Font.c
    ../sls_files_3d_printer/components/: ui_comp_hook.c
  group sls_ebike
    ../sls_files_ebike/: ui.c ui.h ui_helpers.c
    ../sls_files_ebike/screens/: ui_Home.c ui_Settings.c
    ../sls_files_ebike/images/: ui_img_battery_bg_png.c ui_img_ebike_bg_png.c ui_img_gps_bg_png.c ui_img_gps_knob_png.c ui_img_icn_battery_png.c ui_img_icn_bike_png.c ui_img_icn_charge_png.c ui_img_icn_flash_png.c ui_img_icn_map_png.c ui_img_icn_ok_png.c ui_img_icn_settings_png.c ui_img_icn_x_png.c ui_img_icn_x2_png.c ui_img_map_png.c ui_img_menu_line_png.c ui_img_menu_on_png.c ui_img_particle_1_png.c ui_img_particle_2_png.c ui_img_particle_3_png.c ui_img_pin_line_png.c ui_img_pin_on_png.c ui_img_right_png.c ui_img_settings_bg_png.c ui_img_settings_corner_png.c ui_img_slider_battery_png.c ui_img_speed_slider_png.c ui_img_volume_off_png.c ui_img_volume_on_png.c ui_img_water_1_png.c ui_img_water_2_png.c
    ../sls_files_ebike/fonts/: ui_font_Big.c ui_font_Medium.c ui_font_Number.c ui_font_Small.c
    ../sls_files_ebike/components/: ui_comp.c ui_comp_dropdown.c ui_comp_hook.c ui_comp_roller.c
target EBike_LCD5_V1_2 (6240000::V6.24::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.4-rc.3
  cpu: as above
  output: lvgl_ebike_lcd5_v1_2
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=4 wLevel=3
  c define: __800x480__ LV_CONF_INCLUDE_SIMPLE NVT_DCACHE_ON SLS_EBIKE=1 CONFIG_DISP_LT7381=1 __FREERTOS__=1 CONFIG_DISP_LINE_BUFFER_NUMBER=DISP_VER_RES_MAX/2
  c misc: -include ../ffconf.h
  c include: as above
  asm define: M55M1
  asm include: ..\
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\M55M1.scatter
target 3D_Printer_LCD5_V1_2 (6240000::V6.24::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.4-rc.3
  cpu: as above
  output: lvgl_3d_printer_lcd5_v1_2
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=4 wLevel=3
  c define: __800x480__ LV_CONF_INCLUDE_SIMPLE NVT_DCACHE_ON SLS_3D_PRINTER CONFIG_DISP_LT7381=1 __FREERTOS__=1 CONFIG_DISP_LINE_BUFFER_NUMBER=DISP_VER_RES_MAX/2
  c misc: -include ../ffconf.h
  c include: as above
  asm define: M55M1
  asm include: ..\
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\M55M1.scatter
target EBike_LCD43_V1_1 (6240000::V6.24::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.4-rc.3
  cpu: as above
  output: lvgl_ebike_lcd43_v1_1
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=4 wLevel=3
  c define: __480x272__ LV_CONF_INCLUDE_SIMPLE NVT_DCACHE_ON SLS_EBIKE_480x272=1 CONFIG_DISP_NV3041A=1 __FREERTOS__=1
  c misc: -include ../ffconf.h
  c include: as above
  asm define: M55M1
  asm include: ..\
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\M55M1.scatter
target EBike_LCD43_V1_0 (6240000::V6.24::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.4-rc.3
  cpu: as above
  output: lvgl_ebike_lcd43_v1_0
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=4 wLevel=3
  c define: __480x272__ LV_CONF_INCLUDE_SIMPLE NVT_DCACHE_ON SLS_EBIKE_480x272=1 CONFIG_DISP_FSA506=1 __FREERTOS__=1
  c misc: -include ../ffconf.h
  c include: as above
  asm define: M55M1
  asm include: ..\
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\M55M1.scatter
