# Keil uVision project XIP_Loader.uvprojx, settings and files
target NORFlash (6240000::V6.24::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.4-rc.3
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: xip_loader_norflash
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  AfterMake: fromelf --bin "$L@L.axf" --output "$P../Bin/@L.bin"
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=4 wLevel=3
  c define: DEF_USE_SPIM_NORFLASH=1
  c include: ..\;..\..\..\board\numaker-x-m55m1d\plat_driver\spim_hyperram;..\..\..\board\numaker-x-m55m1d\plat_driver\spim_hyperflash;..\..\..\board\numaker-x-m55m1d\plat_driver\gdma;..\..\..\board\numaker-x-m55m1d\plat_driver\;..\..\..\board\numaker-x-m55m1d;..\..\..\bsp\m55m1\Library\CMSIS\DSP\Include;..\..\..\bsp\M55M1\Library\CMSIS\Core\Include;..\..\..\bsp\M55M1\Library\Device\Nuvoton\M55M1\Include;..\..\..\bsp\M55M1\Library\StdDriver\inc
  asm define: M55M1
  asm include: ..\
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\M55M1_XIP_APROM.scatter
  group src
    ../: xip_loader.c
  group libraries
    ../../../bsp/m55m1/Library/StdDriver/src/: crc.c clk.c gpio.c retarget.c sys.c uart.c spim.c spim_hyper.c
    ../../../bsp/m55m1/Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group spim_norflash
    ../../../board/numaker-x-m55m1d/plat_driver/spim_norflash/: cmdcode.c norflash_code.c
  group spim_hyperflash
    ../../../board/numaker-x-m55m1d/plat_driver/spim_hyperflash/: hyperflash_code.c
target HyperFlash (6240000::V6.24::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.4-rc.3
  cpu: as above
  output: xip_loader_hyperflash
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  AfterMake: fromelf --bin "$L@L.axf" --output "$P../Bin/@L.bin"
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=4 wLevel=3
  c define: DEF_USE_SPIM_HYPERFLASH=1
  c include: ..\;..\..\..\board\numaker-x-m55m1d\plat_driver\spim_hyperram;..\..\..\board\numaker-x-m55m1d\plat_driver\gdma;..\..\..\board\numaker-x-m55m1d\plat_driver\;..\..\..\board\numaker-x-m55m1d;..\..\..\bsp\m55m1\Library\CMSIS\DSP\Include;..\..\..\bsp\M55M1\Library\CMSIS\Core\Include;..\..\..\bsp\M55M1\Library\Device\Nuvoton\M55M1\Include;..\..\..\bsp\M55M1\Library\StdDriver\inc
  asm define: M55M1
  asm include: ..\
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\M55M1_XIP_APROM.scatter
