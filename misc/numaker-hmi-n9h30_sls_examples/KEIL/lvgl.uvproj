# Keil uVision project lvgl.uvproj, settings and files
target N9H30_3D_Printer (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: lvgl_n9h30_3d_printer
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: fromelf --bin "$L@L.axf" --output "$P../Bin/@L.bin"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: __800x480__ LV_CONF_INCLUDE_SIMPLE
  c misc: --min_array_alignment=4
  c include: ..\;..\lv_port;..\..\..\bsp\n9h30\Driver\Include;..\..\..\thirdparty\FreeRTOS\include;..\..\..\thirdparty\FreeRTOS\portable\RVDS\ARM9_N9H30;..\..\..\common\drv_disp;..\..\..\common\drv_indev;..\..\..\common;..\..\..\lvgl\src;..\..\..\lvgl\src\core;..\..\..\lvgl\src\draw;..\..\..\lvgl\src\draw\sw;..\..\..\lvgl\src\font;..\..\..\lvgl\src\misc;..\..\..\lvgl\src\widgets;..\..\..\lvgl\demos\;..\..\..\lvgl\demos\benchmark;..\..\..\lvgl\demos\music;..\..\..\lvgl\demos\stress;..\..\..\lvgl\demos\widgets;..\..\..\lvgl\demos\music\assets;..\..\..\lvgl\demos\keypad_encoder;..\..\..\
  asm define: N9H30F6
  asm include: ..\
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\bsp\n9h30\Script\N9H30.sct
  link misc: --entry 0x0
  group src
    ../: main.c FreeRTOSConfig.h multithread.c
    ../components/: task_lv.c
  group libraries
    ../../../bsp/n9h30/Driver/Source/: standalone.c sys.c sys_timer.c sys_uart.c system_N9H30.c startup_N9H30.s sys_N9H30.s 2d.c adc.c lcd.c
  group FreeRTOS
    ../../../thirdparty/FreeRTOS/: list.c queue.c tasks.c timers.c
    ../../../thirdparty/FreeRTOS/portable/RVDS/ARM9_N9H30/: port.c portASM.s
    ../../../thirdparty/FreeRTOS/portable/MemMang/: heap_4.c
  group lv_port
    ../lv_port/: lv_port_disp.c lv_glue.c
    ../../../common/: lv_port_indev.c nu_misc.c
    ../: lv_conf.h
    ../../../common/drv_indev/: touch_adc_calibration.c
  group lv_draw
    ../../../common/drv_draw/2dge/: lv_draw_2dge.c lv_draw_2dge_fill.c lv_draw_2dge_image.c lv_draw_2dge_layer.c drv_2dge.c
  group lvgl
    ../../../lvgl/src/: lv_init.c
    ../../../lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
    ../../../lvgl/src/display/: lv_display.c
    ../../../lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../../../lvgl/src/draw/convert/: lv_draw_buf_convert.c
    ../../../lvgl/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    ../../../lvgl/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    ../../../lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../../../lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../../../lvgl/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    ../../../lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../../../lvgl/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../../../lvgl/src/layouts/: lv_layout.c
    ../../../lvgl/src/layouts/flex/: lv_flex.c
    ../../../lvgl/src/layouts/grid/: lv_grid.c
    ../../../lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../../../lvgl/src/libs/bmp/: lv_bmp.c
    ../../../lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
    ../../../lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_frogfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
    ../../../lvgl/src/libs/gif/: lv_gif.c
    ../../../lvgl/src/libs/gif/AnimatedGIF/src/: gif.c
    ../../../lvgl/src/libs/libpng/: lv_libpng.c
    ../../../lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ../../../lvgl/src/libs/lz4/: lz4.c
    ../../../lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    ../../../lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../../../lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../../../lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../../../lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../../../lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
    ../../../lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../../../lvgl/src/others/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../../../lvgl/src/others/gridnav/: lv_gridnav.c
    ../../../lvgl/src/others/ime/: lv_ime_pinyin.c
    ../../../lvgl/src/others/imgfont/: lv_imgfont.c
    ../../../lvgl/src/others/monkey/: lv_monkey.c
    ../../../lvgl/src/others/observer/: lv_observer.c
    ../../../lvgl/src/others/snapshot/: lv_snapshot.c
    ../../../lvgl/src/others/sysmon/: lv_sysmon.c
    ../../../lvgl/src/others/translation/: lv_translation.c
    ../../../lvgl/src/others/vg_lite_tvg/: vg_lite_matrix.c
    ../../../lvgl/src/stdlib/: lv_mem.c
    ../../../lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../../../lvgl/src/themes/: lv_theme.c
    ../../../lvgl/src/themes/default/: lv_theme_default.c
    ../../../lvgl/src/themes/mono/: lv_theme_mono.c
    ../../../lvgl/src/themes/simple/: lv_theme_simple.c
    ../../../lvgl/src/tick/: lv_tick.c
    ../../../lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ../../../lvgl/src/widgets/animimage/: lv_animimage.c
    ../../../lvgl/src/widgets/arc/: lv_arc.c
    ../../../lvgl/src/widgets/arclabel/: lv_arclabel.c
    ../../../lvgl/src/widgets/bar/: lv_bar.c
    ../../../lvgl/src/widgets/button/: lv_button.c
    ../../../lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../../../lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../../lvgl/src/widgets/canvas/: lv_canvas.c
    ../../../lvgl/src/widgets/chart/: lv_chart.c
    ../../../lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../../../lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../../../lvgl/src/widgets/image/: lv_image.c
    ../../../lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../../../lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../../../lvgl/src/widgets/label/: lv_label.c
    ../../../lvgl/src/widgets/led/: lv_led.c
    ../../../lvgl/src/widgets/line/: lv_line.c
    ../../../lvgl/src/widgets/list/: lv_list.c
    ../../../lvgl/src/widgets/lottie/: lv_lottie.c
    ../../../lvgl/src/widgets/menu/: lv_menu.c
    ../../../lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../../../lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../../../lvgl/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
    ../../../lvgl/src/widgets/roller/: lv_roller.c
    ../../../lvgl/src/widgets/scale/: lv_scale.c
    ../../../lvgl/src/widgets/slider/: lv_slider.c
    ../../../lvgl/src/widgets/span/: lv_span.c
    ../../../lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../../../lvgl/src/widgets/spinner/: lv_spinner.c
    ../../../lvgl/src/widgets/switch/: lv_switch.c
    ../../../lvgl/src/widgets/table/: lv_table.c
    ../../../lvgl/src/widgets/tabview/: lv_tabview.c
    ../../../lvgl/src/widgets/textarea/: lv_textarea.c
    ../../../lvgl/src/widgets/tileview/: lv_tileview.c
    ../../../lvgl/src/widgets/win/: lv_win.c
  group sls_ui_ebike
    ../sls_files_ebike/: ui.c ui_helpers.c
    ../sls_files_ebike/screens/: ui_Home.c ui_Settings.c
    ../sls_files_ebike/images/: ui_img_battery_bg_png.c ui_img_ebike_bg_png.c ui_img_gps_bg_png.c ui_img_gps_knob_png.c ui_img_icn_battery_png.c ui_img_icn_bike_png.c ui_img_icn_charge_png.c ui_img_icn_flash_png.c ui_img_icn_map_png.c ui_img_icn_ok_png.c ui_img_icn_settings_png.c ui_img_icn_x_png.c ui_img_icn_x2_png.c ui_img_map_png.c ui_img_menu_line_png.c ui_img_menu_on_png.c ui_img_particle_1_png.c ui_img_particle_2_png.c ui_img_particle_3_png.c ui_img_pin_line_png.c ui_img_pin_on_png.c ui_img_right_png.c ui_img_settings_bg_png.c ui_img_settings_corner_png.c ui_img_slider_battery_png.c ui_img_speed_slider_png.c ui_img_volume_off_png.c ui_img_volume_on_png.c ui_img_water_1_png.c ui_img_water_2_png.c
    ../sls_files_ebike/fonts/: ui_font_Big.c ui_font_Medium.c ui_font_Number.c ui_font_Small.c
    ../sls_files_ebike/components/: ui_comp.c ui_comp_dropdown.c ui_comp_hook.c ui_comp_roller.c
  group sls_ui_3d_printer
    ../sls_files_3d_printer/: ui.c ui_helpers.c
    ../sls_files_3d_printer/screens/: ui_Screen_1_Print.c ui_Screen_2_Move.c ui_Screen_3_Setting.c
    ../sls_files_3d_printer/images/: ui_img_3d_printer_bg_png.c ui_img_arrow_down_png.c ui_img_arrow_left_png.c ui_img_arrow_right_png.c ui_img_arrow_up_png.c ui_img_btn_main_off_png.c ui_img_btn_main_on_png.c ui_img_btn_move_png.c ui_img_btn_pad_bottom_png.c ui_img_btn_pad_top_png.c ui_img_btn_print_down_png.c ui_img_btn_print_png.c ui_img_btn_print_top_off_png.c ui_img_btn_setting_png.c ui_img_btn_z_botton_png.c ui_img_btn_z_top_png.c ui_img_icn_bed_png.c ui_img_icn_head_png.c ui_img_icn_pause_png.c ui_img_icn_pc_png.c ui_img_icn_stop_png.c ui_img_icn_time_1_png.c ui_img_icn_time_2_png.c ui_img_icn_usb_png.c ui_img_icn_wifi_png.c ui_img_print_view_bg_png.c ui_img_print_view_front_png.c ui_img_roller_bg_png.c
    ../sls_files_3d_printer/fonts/: ui_font_Small_Font.c
    ../sls_files_3d_printer/components/: ui_comp_hook.c
target N9H30_EBike (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: lvgl_n9h30_ebike
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: fromelf --bin "$L@L.axf" --output "$P../Bin/@L.bin"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: __800x480__ LV_CONF_INCLUDE_SIMPLE
  c misc: --min_array_alignment=4
  c include: ..\;..\lv_port;..\..\..\bsp\n9h30\Driver\Include;..\..\..\thirdparty\FreeRTOS\include;..\..\..\thirdparty\FreeRTOS\portable\RVDS\ARM9_N9H30;..\..\..\common\drv_disp;..\..\..\common\drv_indev;..\..\..\common;..\..\..\lvgl\src;..\..\..\lvgl\src\core;..\..\..\lvgl\src\draw;..\..\..\lvgl\src\draw\sw;..\..\..\lvgl\src\font;..\..\..\lvgl\src\misc;..\..\..\lvgl\src\widgets;..\..\..\lvgl\demos\;..\..\..\lvgl\demos\benchmark;..\..\..\lvgl\demos\music;..\..\..\lvgl\demos\stress;..\..\..\lvgl\demos\widgets;..\..\..\lvgl\demos\music\assets;..\..\..\lvgl\demos\keypad_encoder;..\..\..\;..\sls_files
  asm define: N9H30F6
  asm include: ..\
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\bsp\n9h30\Script\N9H30.sct
  link misc: --entry 0x0
