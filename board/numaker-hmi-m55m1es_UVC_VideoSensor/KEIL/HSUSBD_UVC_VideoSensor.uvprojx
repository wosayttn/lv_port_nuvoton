# Keil uVision project HSUSBD_UVC_VideoSensor.uvprojx, settings and files
target HSUSBD_UVC_VideoSensor (6180000::V6.18::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: HSUSBD_UVC_VideoSensor
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c include: ..\..\..\bsp\m55m1\Library\CMSIS\Core\Include;..\..\..\bsp\m55m1\Library\Device\Nuvoton\M55M1\Include;..\..\..\bsp\m55m1\Library\StdDriver\inc;..\..\HSUSBD_UVC_VideoSensor
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: ..\..\..\bsp\m55m1\Library\Device\Nuvoton\M55M1\Source\ARM\M55M1.scatter
  group CMSIS
    ../../../bsp/m55m1/Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group User
    ../: main.c descriptors.c uvc.c i2c_gpio.c Sensor_HM1055.c
  group Library
    ../../../bsp/m55m1/Library/StdDriver/src/: clk.c sys.c uart.c hsusbd.c retarget.c ccap.c gpio.c
