# Keil uVision project gdma_spim_hyperram.uvprojx, settings and files
target spim_cache_off (6240000::V6.24::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.4-rc.3
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: gdma_spim_hyperram
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  AfterMake: fromelf --bin "$L@L.axf" --output "$P../Bin/@L.bin"
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=4 wLevel=3
  c define: NVT_DCACHE_ON=0 _DEBUG=1  CONFIG_SPIM_CACHE_ON=0
  c include: ..\;..\tc;..\gdma;..\spim_hyperram;..\..\..\common;..\..\..\bsp\M55M1\Library\CMSIS\Core\Include;..\..\..\bsp\M55M1\Library\Device\Nuvoton\M55M1\Include;..\..\..\bsp\M55M1\Library\StdDriver\inc
  asm define: M55M1
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\M55M1.scatter
  group src
    ../: main.c mpu_config_M55M1.h
  group libraries
    ../../../bsp/m55m1/Library/StdDriver/src/: clk.c retarget.c sys.c uart.c spim.c spim_hyper.c gpio.c pdma.c
    ../../../bsp/m55m1/Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
    ../gdma/: dma350_ch_drv.c dma350_drv.c dma350_lib.c
    ../../../common/: nu_bitutil.h
  group tc
    ../tc/: tc_pdma.c tc.c nu_misc.c tc_gdma.c tc_001.c tc_002.c tc_003.c tc_006.c tc_boundary_crossing.c tc_007a.c tc_007b.c tc_007c.c tc_007d.c tc_007e.c tc_007f.c
    ../spim_hyperram/: hyperram_code.c
