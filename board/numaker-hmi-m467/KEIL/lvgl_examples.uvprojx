# Keil uVision project lvgl_examples.uvprojx, settings and files
target M467HJ_USE_NUMAKER_TFT_LCD43_V_1_1 (6220000::V6.22::ARMCLANG)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicroM4_DFP.1.0.0
  cpu: IRAM(0x20000000,0x80000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: lvgl_examples_m467hj_use_numaker_tft_lcd43_v_1_1
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  AfterMake: fromelf --bin "$L@L.axf" --output "$P../Bin/@L.bin"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: __480x272__ CPU_CORTEX_M4 LV_CONF_INCLUDE_SIMPLE USE_NUMAKER_TFT_LCD43_V_1_1
  c include: ..\;..\..\..\bsp\m460\Library\CMSIS\Include;..\..\..\bsp\m460\Library\Device\Nuvoton\m460\Include;..\..\..\bsp\m460\Library\StdDriver\inc;..\..\..\thirdparty\FreeRTOS\portable\GCC\ARM_CM4F;..\..\..\thirdparty\FreeRTOS\include;..\..\..\common;..\..\..\common\drv_disp;..\..\..\common\drv_indev;..\lv_port;..\..\..\lvgl\src;..\..\..\lvgl\src\core;..\..\..\lvgl\src\draw;..\..\..\lvgl\src\draw\sw;..\..\..\lvgl\src\font;..\..\..\lvgl\src\misc;..\..\..\lvgl\src\widgets;..\..\..\lvgl\demos\;..\..\..\lvgl\demos\benchmark;..\..\..\lvgl\demos\music;..\..\..\lvgl\demos\stress;..\..\..\lvgl\demos\widgets;..\..\..\lvgl\demos\music\assets;..\..\..\lvgl\demos\keypad_encoder;..\..\..\lvgl\examples;..\..\..\;..\sls_files
  asm define: M467HJ
  asm include: ..\
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --map --first='startup_m460.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group libraries
    ../../../bsp/m460/Library/StdDriver/src/: clk.c ebi.c gpio.c pdma.c retarget.c sys.c uart.c i2c.c spi.c eadc.c
    ../../../bsp/m460/Library/Device/Nuvoton/m460/Source/: system_m460.c
    ../../../bsp/m460/Library/Device/Nuvoton/m460/Source/ARM/: startup_m460.s
  group FreeRTOS
    ../../../thirdparty/FreeRTOS/: list.c queue.c tasks.c timers.c
    ../../../thirdparty/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../thirdparty/FreeRTOS/portable/GCC/ARM_CM4F/: port.c
  group NUMAKER_TFT_LCD43_V_1_1
    ../../../common/drv_indev/: touch_gt911.c
    ../../../common/drv_disp/: nv3041a_ebi.c disp_nv3041a.c
  group lv_port
    ../../../common/: lv_port_disp.c lv_port_indev.c nu_misc.c lv_example_entry.c
    ../lv_port/: lv_glue.c lv_glue.h drv_pdma.c
    ../: lv_conf.h
  group lvgl
    ../../../lvgl/src/: lv_init.c
    ../../../lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
    ../../../lvgl/src/display/: lv_display.c
    ../../../lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../../../lvgl/src/draw/convert/: lv_draw_buf_convert.c
    ../../../lvgl/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    ../../../lvgl/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    ../../../lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../../../lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../../../lvgl/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    ../../../lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../../../lvgl/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../../../lvgl/src/layouts/: lv_layout.c
    ../../../lvgl/src/layouts/flex/: lv_flex.c
    ../../../lvgl/src/layouts/grid/: lv_grid.c
    ../../../lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../../../lvgl/src/libs/bmp/: lv_bmp.c
    ../../../lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
    ../../../lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_frogfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
    ../../../lvgl/src/libs/gif/: lv_gif.c
    ../../../lvgl/src/libs/gif/AnimatedGIF/src/: gif.c
    ../../../lvgl/src/libs/libpng/: lv_libpng.c
    ../../../lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ../../../lvgl/src/libs/lz4/: lz4.c
    ../../../lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    ../../../lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../../../lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../../../lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../../../lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../../../lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
    ../../../lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../../../lvgl/src/others/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../../../lvgl/src/others/gridnav/: lv_gridnav.c
    ../../../lvgl/src/others/ime/: lv_ime_pinyin.c
    ../../../lvgl/src/others/imgfont/: lv_imgfont.c
    ../../../lvgl/src/others/monkey/: lv_monkey.c
    ../../../lvgl/src/others/observer/: lv_observer.c
    ../../../lvgl/src/others/snapshot/: lv_snapshot.c
    ../../../lvgl/src/others/sysmon/: lv_sysmon.c
    ../../../lvgl/src/others/translation/: lv_translation.c
    ../../../lvgl/src/others/vg_lite_tvg/: vg_lite_matrix.c
    ../../../lvgl/src/stdlib/: lv_mem.c
    ../../../lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../../../lvgl/src/themes/: lv_theme.c
    ../../../lvgl/src/themes/default/: lv_theme_default.c
    ../../../lvgl/src/themes/mono/: lv_theme_mono.c
    ../../../lvgl/src/themes/simple/: lv_theme_simple.c
    ../../../lvgl/src/tick/: lv_tick.c
    ../../../lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ../../../lvgl/src/widgets/animimage/: lv_animimage.c
    ../../../lvgl/src/widgets/arc/: lv_arc.c
    ../../../lvgl/src/widgets/arclabel/: lv_arclabel.c
    ../../../lvgl/src/widgets/bar/: lv_bar.c
    ../../../lvgl/src/widgets/button/: lv_button.c
    ../../../lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../../../lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../../lvgl/src/widgets/canvas/: lv_canvas.c
    ../../../lvgl/src/widgets/chart/: lv_chart.c
    ../../../lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../../../lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../../../lvgl/src/widgets/image/: lv_image.c
    ../../../lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../../../lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../../../lvgl/src/widgets/label/: lv_label.c
    ../../../lvgl/src/widgets/led/: lv_led.c
    ../../../lvgl/src/widgets/line/: lv_line.c
    ../../../lvgl/src/widgets/list/: lv_list.c
    ../../../lvgl/src/widgets/lottie/: lv_lottie.c
    ../../../lvgl/src/widgets/menu/: lv_menu.c
    ../../../lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../../../lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../../../lvgl/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
    ../../../lvgl/src/widgets/roller/: lv_roller.c
    ../../../lvgl/src/widgets/scale/: lv_scale.c
    ../../../lvgl/src/widgets/slider/: lv_slider.c
    ../../../lvgl/src/widgets/span/: lv_span.c
    ../../../lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../../../lvgl/src/widgets/spinner/: lv_spinner.c
    ../../../lvgl/src/widgets/switch/: lv_switch.c
    ../../../lvgl/src/widgets/table/: lv_table.c
    ../../../lvgl/src/widgets/tabview/: lv_tabview.c
    ../../../lvgl/src/widgets/textarea/: lv_textarea.c
    ../../../lvgl/src/widgets/tileview/: lv_tileview.c
    ../../../lvgl/src/widgets/win/: lv_win.c
  group lv_examples
    ../../../lvgl/examples/anim/: lv_example_anim_1.c lv_example_anim_2.c lv_example_anim_3.c lv_example_anim_4.c lv_example_anim_timeline_1.c
    ../../../lvgl/examples/assets/: animimg001.c animimg002.c animimg003.c imgbtn_left.c imgbtn_mid.c imgbtn_right.c img_caret_down.c img_cogwheel_argb.c img_cogwheel_indexed16.c img_cogwheel_rgb.c img_hand.c img_skew_strip.c img_star.c img_svg_img.c
    ../../../lvgl/examples/assets/emoji/: img_emoji_F617.c
    ../../../lvgl/examples/event/: lv_example_event_bubble.c lv_example_event_button.c lv_example_event_click.c lv_example_event_draw.c lv_example_event_streak.c lv_example_event_trickle.c
    ../../../lvgl/examples/get_started/: lv_example_get_started_1.c lv_example_get_started_2.c lv_example_get_started_3.c lv_example_get_started_4.c
    ../../../lvgl/examples/grad/: lv_example_grad_1.c lv_example_grad_2.c lv_example_grad_3.c lv_example_grad_4.c
    ../../../lvgl/examples/layouts/flex/: lv_example_flex_1.c lv_example_flex_2.c lv_example_flex_3.c lv_example_flex_4.c lv_example_flex_5.c lv_example_flex_6.c
    ../../../lvgl/examples/layouts/grid/: lv_example_grid_1.c lv_example_grid_2.c lv_example_grid_3.c lv_example_grid_4.c lv_example_grid_5.c lv_example_grid_6.c
    ../../../lvgl/examples/libs/barcode/: lv_example_barcode_1.c
    ../../../lvgl/examples/libs/bmp/: lv_example_bmp_1.c
    ../../../lvgl/examples/libs/ffmpeg/: lv_example_ffmpeg_1.c lv_example_ffmpeg_2.c
    ../../../lvgl/examples/libs/freetype/: lv_example_freetype_1.c lv_example_freetype_2.c lv_example_freetype_3.c
    ../../../lvgl/examples/libs/gif/: img_bulb_gif.c lv_example_gif_1.c
    ../../../lvgl/examples/libs/gltf/: lv_example_gltf_1.c lv_example_gltf_2.c
    ../../../lvgl/examples/libs/gstreamer/: lv_example_gstreamer_1.c
    ../../../lvgl/examples/libs/libjpeg_turbo/: lv_example_libjpeg_turbo_1.c
    ../../../lvgl/examples/libs/libpng/: img_png_demo.c lv_example_libpng_1.c
    ../../../lvgl/examples/libs/lodepng/: img_wink_png.c lv_example_lodepng_1.c
    ../../../lvgl/examples/libs/qrcode/: lv_example_qrcode_1.c
    ../../../lvgl/examples/libs/rlottie/: lv_example_rlottie_1.c lv_example_rlottie_2.c lv_example_rlottie_approve.c
    ../../../lvgl/examples/libs/svg/: lv_example_svg_1.c lv_example_svg_2.c lv_example_svg_3.c
    ../../../lvgl/examples/libs/tiny_ttf/: lv_example_tiny_ttf_1.c lv_example_tiny_ttf_2.c lv_example_tiny_ttf_3.c ubuntu_font.c
    ../../../lvgl/examples/libs/tjpgd/: lv_example_tjpgd_1.c
    ../../../lvgl/examples/others/file_explorer/: lv_example_file_explorer_1.c lv_example_file_explorer_2.c lv_example_file_explorer_3.c
    ../../../lvgl/examples/others/font_manager/: lv_example_font_manager_1.c lv_example_font_manager_2.c lv_example_font_manager_3.c
    ../../../lvgl/examples/others/fragment/: lv_example_fragment_1.c lv_example_fragment_2.c
    ../../../lvgl/examples/others/gestures/: lv_example_gestures.c
    ../../../lvgl/examples/others/gridnav/: lv_example_gridnav_1.c lv_example_gridnav_2.c lv_example_gridnav_3.c lv_example_gridnav_4.c lv_example_gridnav_5.c
    ../../../lvgl/examples/others/ime/: lv_example_ime_pinyin_1.c lv_example_ime_pinyin_2.c
    ../../../lvgl/examples/others/imgfont/: lv_example_imgfont_1.c
    ../../../lvgl/examples/others/monkey/: lv_example_monkey_1.c lv_example_monkey_2.c lv_example_monkey_3.c
    ../../../lvgl/examples/others/observer/: lv_example_observer_1.c lv_example_observer_2.c lv_example_observer_3.c lv_example_observer_4.c lv_example_observer_5.c lv_example_observer_6.c lv_example_observer_7.c
    ../../../lvgl/examples/others/snapshot/: lv_example_snapshot_1.c
    ../../../lvgl/examples/others/translation/: lv_example_translation_1.c lv_example_translation_2.c
    ../../../lvgl/examples/others/xml/: lv_example_xml_1.c lv_example_xml_2.c
    ../../../lvgl/examples/porting/: lv_port_disp_template.c lv_port_fs_template.c lv_port_indev_template.c lv_port_lcd_stm32_template.c
    ../../../lvgl/examples/porting/osal/: lv_example_osal.c
    ../../../lvgl/examples/scroll/: lv_example_scroll_1.c lv_example_scroll_2.c lv_example_scroll_3.c lv_example_scroll_4.c lv_example_scroll_5.c lv_example_scroll_6.c lv_example_scroll_7.c lv_example_scroll_8.c
    ../../../lvgl/examples/styles/: lv_example_style_1.c lv_example_style_10.c lv_example_style_11.c lv_example_style_12.c lv_example_style_13.c lv_example_style_14.c lv_example_style_15.c lv_example_style_16.c lv_example_style_17.c lv_example_style_18.c lv_example_style_19.c lv_example_style_2.c lv_example_style_3.c lv_example_style_4.c lv_example_style_5.c lv_example_style_6.c lv_example_style_7.c lv_example_style_8.c lv_example_style_9.c
    ../../../lvgl/examples/widgets/animimg/: lv_example_animimg_1.c
    ../../../lvgl/examples/widgets/arc/: lv_example_arc_1.c lv_example_arc_2.c lv_example_arc_3.c
    ../../../lvgl/examples/widgets/arclabel/: lv_example_arclabel_1.c
    ../../../lvgl/examples/widgets/bar/: lv_example_bar_1.c lv_example_bar_2.c lv_example_bar_3.c lv_example_bar_4.c lv_example_bar_5.c lv_example_bar_6.c lv_example_bar_7.c
    ../../../lvgl/examples/widgets/button/: lv_example_button_1.c lv_example_button_2.c lv_example_button_3.c
    ../../../lvgl/examples/widgets/buttonmatrix/: lv_example_buttonmatrix_1.c lv_example_buttonmatrix_2.c lv_example_buttonmatrix_3.c
    ../../../lvgl/examples/widgets/calendar/: lv_example_calendar_1.c lv_example_calendar_2.c
    ../../../lvgl/examples/widgets/canvas/: lv_example_canvas_1.c lv_example_canvas_10.c lv_example_canvas_11.c lv_example_canvas_2.c lv_example_canvas_3.c lv_example_canvas_4.c lv_example_canvas_5.c lv_example_canvas_6.c lv_example_canvas_7.c lv_example_canvas_8.c lv_example_canvas_9.c
    ../../../lvgl/examples/widgets/chart/: lv_example_chart_1.c lv_example_chart_2.c lv_example_chart_3.c lv_example_chart_4.c lv_example_chart_5.c lv_example_chart_6.c lv_example_chart_7.c lv_example_chart_8.c
    ../../../lvgl/examples/widgets/checkbox/: lv_example_checkbox_1.c lv_example_checkbox_2.c
    ../../../lvgl/examples/widgets/dropdown/: lv_example_dropdown_1.c lv_example_dropdown_2.c lv_example_dropdown_3.c
    ../../../lvgl/examples/widgets/image/: lv_example_image_1.c lv_example_image_2.c lv_example_image_3.c lv_example_image_4.c lv_example_image_5.c
    ../../../lvgl/examples/widgets/imagebutton/: lv_example_imagebutton_1.c
    ../../../lvgl/examples/widgets/keyboard/: lv_example_keyboard_1.c lv_example_keyboard_2.c lv_example_keyboard_3.c
    ../../../lvgl/examples/widgets/label/: lv_example_label_1.c lv_example_label_2.c lv_example_label_3.c lv_example_label_4.c lv_example_label_5.c lv_example_label_6.c lv_example_label_7.c
    ../../../lvgl/examples/widgets/led/: lv_example_led_1.c
    ../../../lvgl/examples/widgets/line/: lv_example_line_1.c
    ../../../lvgl/examples/widgets/list/: lv_example_list_1.c lv_example_list_2.c
    ../../../lvgl/examples/widgets/lottie/: lv_example_lottie_1.c lv_example_lottie_2.c lv_example_lottie_approve.c
    ../../../lvgl/examples/widgets/menu/: lv_example_menu_1.c lv_example_menu_2.c lv_example_menu_3.c lv_example_menu_4.c lv_example_menu_5.c
    ../../../lvgl/examples/widgets/msgbox/: lv_example_msgbox_1.c lv_example_msgbox_2.c
    ../../../lvgl/examples/widgets/obj/: lv_example_obj_1.c lv_example_obj_2.c lv_example_obj_3.c
    ../../../lvgl/examples/widgets/roller/: lv_example_roller_1.c lv_example_roller_2.c lv_example_roller_3.c
    ../../../lvgl/examples/widgets/scale/: lv_example_scale_1.c lv_example_scale_10.c lv_example_scale_11.c lv_example_scale_12.c lv_example_scale_2.c lv_example_scale_3.c lv_example_scale_4.c lv_example_scale_5.c lv_example_scale_6.c lv_example_scale_7.c lv_example_scale_8.c lv_example_scale_9.c
    ../../../lvgl/examples/widgets/slider/: lv_example_slider_1.c lv_example_slider_2.c lv_example_slider_3.c lv_example_slider_4.c
    ../../../lvgl/examples/widgets/span/: lv_example_span_1.c
    ../../../lvgl/examples/widgets/spinbox/: lv_example_spinbox_1.c
    ../../../lvgl/examples/widgets/spinner/: lv_example_spinner_1.c
    ../../../lvgl/examples/widgets/switch/: lv_example_switch_1.c lv_example_switch_2.c
    ../../../lvgl/examples/widgets/table/: lv_example_table_1.c lv_example_table_2.c
    ../../../lvgl/examples/widgets/tabview/: lv_example_tabview_1.c lv_example_tabview_2.c
    ../../../lvgl/examples/widgets/textarea/: lv_example_textarea_1.c lv_example_textarea_2.c lv_example_textarea_3.c lv_example_textarea_4.c
    ../../../lvgl/examples/widgets/tileview/: lv_example_tileview_1.c
    ../../../lvgl/examples/widgets/win/: lv_example_win_1.c
  group src
    ../: main.c FreeRTOSConfig.h
    ../components/: task_lv.c
