# Keil uVision project lvgl_examples.uvprojx, settings and files
target M3351KJ_NUTFT (6240000::V6.24::ARMCLANG)
  device: M3351KJCAE Nuvoton
  pack: Nuvoton.NuMicroM33_DFP.1.0.2
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x30000000,0x20000) IROM(0x00000000,0x100000) IROM2(0x10000000,0x100000) IROM3(0x0F100000,0x4000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: lvgl_examples_m3351kj_nutft
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  AfterMake: fromelf --bin "$L@L.axf" --output "$P../Bin/@L.bin"
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=3
  c define: __320x240__ CPU_CORTEX_M33 LV_CONF_INCLUDE_SIMPLE __FREERTOS__=1 CONFIG_DISP_ILI9341=1
  c include: ..\;..\..\..\bsp\m3351\Library\CMSIS\Core\Include;..\..\..\bsp\m3351\Library\Device\Nuvoton\m3351\Include;..\..\..\bsp\m3351\Library\CMSIS\Compiler\include;..\..\..\bsp\m3351\Library\StdDriver\inc;..\..\..\thirdparty\FreeRTOS\portable\GCC\ARM_CM33\non_secure;..\..\..\thirdparty\FreeRTOS\include;..\..\..\common;..\..\..\common\drv_disp;..\..\..\common\drv_indev;..\plat_driver;..\..\..\lvgl\src;..\..\..\lvgl\src\core;..\..\..\lvgl\src\draw;..\..\..\lvgl\src\draw\sw;..\..\..\lvgl\src\font;..\..\..\lvgl\src\misc;..\..\..\lvgl\src\widgets;..\..\..\lvgl\examples;..\..\..\;..\sls_files
  asm define: M3351KJ
  asm include: ..\
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: .\M3351.scf
  group src
    ../: main.c FreeRTOSConfig.h
    ../components/: task_lv.c
  group libraries
    ../../../bsp/m3351/Library/StdDriver/src/: clk.c gpio.c pdma.c retarget.c sys.c uart.c eadc.c spi.c
    ../../../bsp/m3351/Library/Device/Nuvoton/m3351/Source/: system_M3351.c
    ../../../bsp/m3351/Library/Device/Nuvoton/M3351/Source/: startup_M3351.c
  group lvgl
    ../../../lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_observer.c lv_refr.c
    ../../../lvgl/src/debugging/monkey/: lv_monkey.c
    ../../../lvgl/src/debugging/profiler/: lv_profiler_builtin.c lv_profiler_builtin_posix.c
    ../../../lvgl/src/debugging/sysmon/: lv_sysmon.c
    ../../../lvgl/src/debugging/vg_lite_tvg/: vg_lite_matrix.c
    ../../../lvgl/src/display/: lv_display.c
    ../../../lvgl/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    ../../../lvgl/src/draw/convert/: lv_draw_buf_convert.c
    ../../../lvgl/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    ../../../lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_utils.c lv_draw_vector.c
    ../../../lvgl/src/draw/snapshot/: lv_snapshot.c
    ../../../lvgl/src/draw/sw/blend/arm2d/: lv_blend_arm2d.c
    ../../../lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../../../lvgl/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    ../../../lvgl/src/draw/sw/blend/riscv_v/: lv_draw_sw_blend_riscv_v_to_rgb888.c
    ../../../lvgl/src/draw/sw/blend/sve2/: lv_draw_sw_blend_sve2_to_rgb888.c
    ../../../lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c
    ../../../lvgl/src/font/binfont_loader/: lv_binfont_loader.c
    ../../../lvgl/src/font/fmt_txt/: lv_font_fmt_txt.c
    ../../../lvgl/src/font/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../../../lvgl/src/font/imgfont/: lv_imgfont.c
    ../../../lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../../../lvgl/src/fs/: lv_fs.c lv_fs_fatfs.c lv_fs_frogfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
    ../../../lvgl/src/image/: lv_bin_decoder.c lv_bmp.c lv_image_decoder.c lv_libjpeg_turbo.c lv_libpng.c lv_libwebp.c lv_lodepng.c lv_tjpgd.c
    ../../../lvgl/src/indev/: lv_gridnav.c lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../../../lvgl/src/layouts/flex/: lv_flex.c
    ../../../lvgl/src/layouts/grid/: lv_grid.c
    ../../../lvgl/src/layouts/: lv_layout.c
    ../../../lvgl/src/libs/gif/: gif.c
    ../../../lvgl/src/libs/lodepng/: lodepng.c
    ../../../lvgl/src/libs/lz4/: lz4.c
    ../../../lvgl/src/libs/nanovg/: nanovg.c
    ../../../lvgl/src/libs/tjpgd/: tjpgd.c
    ../../../lvgl/src/logging/: lv_log.c
    ../../../lvgl/src/: lv_init.c
    ../../../lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../../../lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../../../lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../../../lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_bidi_common.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_grad.c lv_iter.c lv_ll.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../../../lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
    ../../../lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../../../lvgl/src/others/translation/: lv_translation.c
    ../../../lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../../../lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../../../lvgl/src/stdlib/: lv_mem.c
    ../../../lvgl/src/themes/default/: lv_theme_default.c
    ../../../lvgl/src/themes/: lv_theme.c
    ../../../lvgl/src/themes/mono/: lv_theme_mono.c
    ../../../lvgl/src/themes/simple/: lv_theme_simple.c
    ../../../lvgl/src/tick/: lv_tick.c
    ../../../lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ../../../lvgl/src/widgets/animimage/: lv_animimage.c
    ../../../lvgl/src/widgets/arc/: lv_arc.c
    ../../../lvgl/src/widgets/arclabel/: lv_arclabel.c
    ../../../lvgl/src/widgets/bar/: lv_bar.c
    ../../../lvgl/src/widgets/button/: lv_button.c
    ../../../lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../../../lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../../lvgl/src/widgets/canvas/: lv_canvas.c
    ../../../lvgl/src/widgets/chart/: lv_chart.c
    ../../../lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../../../lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../../../lvgl/src/widgets/gif/: lv_gif.c
    ../../../lvgl/src/widgets/image/: lv_image.c
    ../../../lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../../../lvgl/src/widgets/ime/: lv_ime_pinyin.c
    ../../../lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../../../lvgl/src/widgets/label/: lv_label.c
    ../../../lvgl/src/widgets/led/: lv_led.c
    ../../../lvgl/src/widgets/line/: lv_line.c
    ../../../lvgl/src/widgets/list/: lv_list.c
    ../../../lvgl/src/widgets/lottie/: lv_lottie.c
    ../../../lvgl/src/widgets/menu/: lv_menu.c
    ../../../lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../../../lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../../../lvgl/src/widgets/property/: lv_animimage_properties.c lv_arc_properties.c lv_bar_properties.c lv_buttonmatrix_properties.c lv_chart_properties.c lv_checkbox_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_led_properties.c lv_line_properties.c lv_menu_properties.c lv_obj_properties.c lv_roller_properties.c lv_scale_properties.c lv_slider_properties.c lv_span_properties.c lv_spinbox_properties.c lv_spinner_properties.c lv_style_properties.c lv_switch_properties.c lv_table_properties.c lv_tabview_properties.c lv_textarea_properties.c
    ../../../lvgl/src/widgets/roller/: lv_roller.c
    ../../../lvgl/src/widgets/scale/: lv_scale.c
    ../../../lvgl/src/widgets/slider/: lv_slider.c
    ../../../lvgl/src/widgets/span/: lv_span.c
    ../../../lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../../../lvgl/src/widgets/spinner/: lv_spinner.c
    ../../../lvgl/src/widgets/switch/: lv_switch.c
    ../../../lvgl/src/widgets/table/: lv_table.c
    ../../../lvgl/src/widgets/tabview/: lv_tabview.c
    ../../../lvgl/src/widgets/textarea/: lv_textarea.c
    ../../../lvgl/src/widgets/tileview/: lv_tileview.c
    ../../../lvgl/src/widgets/win/: lv_win.c
  group plat_driver
    ../../../common/: lv_port_disp.c lv_port_indev.c nu_misc.c lv_example_entry.c
    ../plat_driver/: disp_glue.c drv_pdma.c touch_glue.c drv_spi.c
    ../: lv_conf.h
    ../../../common/drv_disp/: disp_ili9341.c ili9341_spi.c
    ../../../common/drv_indev/: touch_adc.c touch_adc_calibration.c
  group FreeRTOS
    ../../../common/: multithread.c
    ../../../thirdparty/FreeRTOS/: list.c queue.c tasks.c timers.c
    ../../../thirdparty/FreeRTOS/portable/MemMang/: heap_3.c
    ../../../thirdparty/FreeRTOS/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c
  group lv_examples
    ../../../lvgl/examples/anim/: lv_example_anim_1.c lv_example_anim_2.c lv_example_anim_3.c lv_example_anim_4.c lv_example_anim_timeline_1.c
    ../../../lvgl/examples/assets/: animimg001.c animimg002.c animimg003.c font_example_large.c img_arc_bg.c img_arc_indicator.c img_bar_bg.c img_bar_indicator.c img_example_lvgl_logo.c img_hand.c img_multilang_like.c img_skew_strip.c img_star.c img_svg_img.c img_transform_avatar_15.c imgbtn_left.c imgbtn_mid.c imgbtn_right.c
    ../../../lvgl/examples/assets/emoji/: img_emoji_F617.c
    ../../../lvgl/examples/event/: lv_example_event_bubble.c lv_example_event_button.c lv_example_event_click.c lv_example_event_draw.c lv_example_event_streak.c lv_example_event_trickle.c
    ../../../lvgl/examples/get_started/get_started_hello_world/: lv_example_get_started_hello_world.c
    ../../../lvgl/examples/get_started/get_started_slider/: lv_example_get_started_slider.c
    ../../../lvgl/examples/get_started/get_started_styles/: lv_example_get_started_styles.c
    ../../../lvgl/examples/get_started/: lv_example_get_started_button.c
    ../../../lvgl/examples/grad/: lv_example_grad_1.c lv_example_grad_2.c lv_example_grad_3.c lv_example_grad_4.c
    ../../../lvgl/examples/layouts/flex/: lv_example_flex_align.c lv_example_flex_flow.c lv_example_flex_grow.c lv_example_flex_ignore_layout.c lv_example_flex_internal_padding.c lv_example_flex_list.c lv_example_flex_new_track.c lv_example_flex_rtl.c lv_example_flex_win.c
    ../../../lvgl/examples/layouts/grid/: lv_example_grid_align.c lv_example_grid_cell_span.c lv_example_grid_descriptors.c lv_example_grid_fr.c lv_example_grid_ignore_layout.c lv_example_grid_internal_padding.c lv_example_grid_rtl.c lv_example_grid_subgrid.c
    ../../../lvgl/examples/layouts/split/: lv_example_split.c lv_example_split_vertical.c
    ../../../lvgl/examples/libs/barcode/: lv_example_barcode_1.c
    ../../../lvgl/examples/libs/bmp/: lv_example_bmp_1.c
    ../../../lvgl/examples/libs/ffmpeg/: lv_example_ffmpeg_1.c lv_example_ffmpeg_2.c
    ../../../lvgl/examples/libs/freetype/: lv_example_freetype_1.c lv_example_freetype_2.c lv_example_freetype_3.c
    ../../../lvgl/examples/libs/gif/: img_bulb_gif.c lv_example_gif_src.c
    ../../../lvgl/examples/libs/gltf/: lv_example_gltf_1.c lv_example_gltf_2.c lv_example_gltf_3.c lv_example_gltf_4.c
    ../../../lvgl/examples/libs/gstreamer/: lv_example_gstreamer_1.c
    ../../../lvgl/examples/libs/libjpeg_turbo/: lv_example_libjpeg_turbo_1.c
    ../../../lvgl/examples/libs/libpng/: img_png_demo.c lv_example_libpng_1.c
    ../../../lvgl/examples/libs/libwebp/: lv_example_libwebp_1.c
    ../../../lvgl/examples/libs/lodepng/: img_wink_png.c lv_example_lodepng_1.c
    ../../../lvgl/examples/libs/qrcode/qrcode_basic/: lv_example_qrcode_basic.c
    ../../../lvgl/examples/libs/rlottie/: lv_example_rlottie_1.c lv_example_rlottie_2.c lv_example_rlottie_approve.c
    ../../../lvgl/examples/libs/svg/: lv_example_svg_1.c lv_example_svg_2.c lv_example_svg_3.c
    ../../../lvgl/examples/libs/tiny_ttf/: lv_example_tiny_ttf_1.c lv_example_tiny_ttf_2.c lv_example_tiny_ttf_3.c ubuntu_font.c
    ../../../lvgl/examples/libs/tjpgd/: lv_example_tjpgd_1.c
    ../../../lvgl/examples/others/file_explorer/: lv_example_file_explorer_1.c lv_example_file_explorer_2.c lv_example_file_explorer_3.c
    ../../../lvgl/examples/others/font_manager/: lv_example_font_manager_1.c lv_example_font_manager_2.c lv_example_font_manager_3.c
    ../../../lvgl/examples/others/fragment/: lv_example_fragment_1.c lv_example_fragment_2.c
    ../../../lvgl/examples/others/gestures/: lv_example_gestures.c
    ../../../lvgl/examples/others/gridnav/: lv_example_gridnav_1.c lv_example_gridnav_2.c lv_example_gridnav_3.c lv_example_gridnav_4.c lv_example_gridnav_5.c
    ../../../lvgl/examples/others/ime/: lv_example_ime_pinyin_1.c lv_example_ime_pinyin_2.c
    ../../../lvgl/examples/others/imgfont/: lv_example_imgfont_1.c
    ../../../lvgl/examples/others/monkey/: lv_example_monkey_1.c lv_example_monkey_2.c lv_example_monkey_3.c
    ../../../lvgl/examples/others/observer/: lv_example_observer_1.c lv_example_observer_2.c lv_example_observer_3.c lv_example_observer_4.c lv_example_observer_5.c lv_example_observer_6.c lv_example_observer_7.c
    ../../../lvgl/examples/others/snapshot/: lv_example_snapshot_1.c
    ../../../lvgl/examples/others/translation/: lv_example_translation_1.c lv_example_translation_2.c
    ../../../lvgl/examples/porting/: lv_port_disp_template.c lv_port_fs_template.c lv_port_indev_template.c lv_port_lcd_stm32_template.c
    ../../../lvgl/examples/porting/osal/: lv_example_osal.c
    ../../../lvgl/examples/scroll/: lv_example_scroll_chain.c lv_example_scroll_circular.c lv_example_scroll_events.c lv_example_scroll_floating.c lv_example_scroll_infinite.c lv_example_scroll_one.c lv_example_scroll_overview.c lv_example_scroll_properties.c lv_example_scroll_rtl.c lv_example_scroll_scrollable.c lv_example_scroll_scrollbar_mode.c lv_example_scroll_scrollbar_style.c lv_example_scroll_snap.c lv_example_scroll_to.c lv_example_scroll_translate.c
    ../../../lvgl/examples/styles/: lv_example_style_arc.c lv_example_style_background.c lv_example_style_blur.c lv_example_style_border.c lv_example_style_drop_shadow.c lv_example_style_gradient_buttons.c lv_example_style_gradient_conic.c lv_example_style_gradient_radial.c lv_example_style_image.c lv_example_style_line.c lv_example_style_local.c lv_example_style_margin.c lv_example_style_modal.c lv_example_style_multiple.c lv_example_style_opacity_transform.c lv_example_style_outline.c lv_example_style_padding.c lv_example_style_parts_states.c lv_example_style_shadow.c lv_example_style_size_position.c lv_example_style_text.c lv_example_style_theme.c lv_example_style_transform_card.c lv_example_style_transition.c
    ../../../lvgl/examples/widgets/animimg/: lv_example_animimg_play.c
    ../../../lvgl/examples/widgets/arc/: lv_example_arc_bind_value.c lv_example_arc_change_rate.c lv_example_arc_event.c lv_example_arc_img_indicator.c lv_example_arc_knob_widget.c lv_example_arc_mode.c lv_example_arc_pie_chart.c lv_example_arc_rotation.c lv_example_arc_set_angles.c lv_example_arc_styling.c lv_example_arc_value_range.c
    ../../../lvgl/examples/widgets/arclabel/: lv_example_arclabel_curved_text.c
    ../../../lvgl/examples/widgets/bar/: lv_example_bar_bind_value.c lv_example_bar_img_indicator.c lv_example_bar_modes.c lv_example_bar_orientation.c lv_example_bar_styling.c lv_example_bar_value_range.c
    ../../../lvgl/examples/widgets/button/: lv_example_button_basic.c lv_example_button_event.c lv_example_button_states.c lv_example_button_styling.c
    ../../../lvgl/examples/widgets/buttonmatrix/: lv_example_buttonmatrix_button_ctrl.c lv_example_buttonmatrix_button_width.c lv_example_buttonmatrix_event.c lv_example_buttonmatrix_map.c lv_example_buttonmatrix_one_checked.c lv_example_buttonmatrix_popover.c lv_example_buttonmatrix_recolor.c lv_example_buttonmatrix_styling.c
    ../../../lvgl/examples/widgets/calendar/: lv_example_calendar_basic.c lv_example_calendar_chinese.c lv_example_calendar_highlighted_days.c
    ../../../lvgl/examples/widgets/canvas/: lv_example_canvas_alpha.c lv_example_canvas_arc.c lv_example_canvas_blur.c lv_example_canvas_image.c lv_example_canvas_label.c lv_example_canvas_line.c lv_example_canvas_rectangle.c lv_example_canvas_rotate.c lv_example_canvas_triangle.c lv_example_canvas_vector.c lv_example_canvas_wave_text.c lv_example_canvas_windstorm_text.c
    ../../../lvgl/examples/widgets/chart/: lv_example_chart_area_gradient.c lv_example_chart_circular_gap.c lv_example_chart_cursor.c lv_example_chart_pressed_tooltip.c lv_example_chart_recolor_bars.c lv_example_chart_scatter.c lv_example_chart_scrollable.c lv_example_chart_series.c lv_example_chart_ticks_labels.c lv_example_chart_types.c
    ../../../lvgl/examples/widgets/checkbox/: lv_example_checkbox_bind_checked.c lv_example_checkbox_event.c lv_example_checkbox_states.c lv_example_checkbox_styling.c lv_example_checkbox_text.c
    ../../../lvgl/examples/widgets/dropdown/: lv_example_dropdown_bind_value.c lv_example_dropdown_direction.c lv_example_dropdown_event.c lv_example_dropdown_styling.c lv_example_dropdown_text.c
    ../../../lvgl/examples/widgets/image/: lv_example_image_inner_align.c lv_example_image_recolor.c lv_example_image_src.c lv_example_image_svg.c lv_example_image_transformations.c
    ../../../lvgl/examples/widgets/imagebutton/: lv_example_imagebutton_transition.c
    ../../../lvgl/examples/widgets/keyboard/: lv_example_keyboard_custom_draw.c lv_example_keyboard_custom_map.c lv_example_keyboard_modes.c lv_example_keyboard_popovers.c lv_example_keyboard_textarea.c
    ../../../lvgl/examples/widgets/label/: lv_example_label_bind_text.c lv_example_label_long_mode.c lv_example_label_recolor.c lv_example_label_set_text_newline.c lv_example_label_styling.c lv_example_label_text_align.c lv_example_label_translation.c
    ../../../lvgl/examples/widgets/led/: lv_example_led_brightness.c lv_example_led_color.c lv_example_led_styling.c
    ../../../lvgl/examples/widgets/line/: lv_example_line_points.c
    ../../../lvgl/examples/widgets/list/: lv_example_list_reorder.c lv_example_list_sections.c
    ../../../lvgl/examples/widgets/lottie/: lv_example_lottie_approve.c lv_example_lottie_from_data.c lv_example_lottie_from_file.c
    ../../../lvgl/examples/widgets/menu/: lv_example_menu_custom_back_button.c lv_example_menu_floating_button.c lv_example_menu_navigation.c lv_example_menu_root_back_button.c lv_example_menu_sidebar.c lv_example_menu_sub_page.c
    ../../../lvgl/examples/widgets/msgbox/: lv_example_msgbox_blur.c lv_example_msgbox_modal.c lv_example_msgbox_settings.c
    ../../../lvgl/examples/widgets/obj/: lv_example_obj_bind_style.c lv_example_obj_draggable.c lv_example_obj_transform.c
    ../../../lvgl/examples/widgets/roller/: lv_example_roller_bind_value.c lv_example_roller_event.c lv_example_roller_fade_mask.c lv_example_roller_options.c lv_example_roller_styling.c lv_example_roller_visible_rows.c
    ../../../lvgl/examples/widgets/scale/: lv_example_scale_bind_section.c lv_example_scale_compass.c lv_example_scale_heart_rate.c lv_example_scale_label_recolor.c lv_example_scale_modes.c lv_example_scale_needles.c lv_example_scale_range.c lv_example_scale_styling.c lv_example_scale_sunset_sunrise.c lv_example_scale_ticks.c
    ../../../lvgl/examples/widgets/slider/: lv_example_slider_bind_state.c lv_example_slider_bind_value.c lv_example_slider_event.c lv_example_slider_img_indicator.c lv_example_slider_modes.c lv_example_slider_reversed_direction.c lv_example_slider_styling.c lv_example_slider_value_range_orientation.c
    ../../../lvgl/examples/widgets/span/: lv_example_span_hittest.c lv_example_span_styling.c
    ../../../lvgl/examples/widgets/spinbox/: lv_example_spinbox_bind_value.c lv_example_spinbox_format.c lv_example_spinbox_rollover.c lv_example_spinbox_styling.c lv_example_spinbox_value.c lv_example_spinbox_with_buttons.c
    ../../../lvgl/examples/widgets/spinner/: lv_example_spinner_basic.c lv_example_spinner_styling.c
    ../../../lvgl/examples/widgets/switch/: lv_example_switch_event.c lv_example_switch_orientation.c lv_example_switch_state.c lv_example_switch_styling.c
    ../../../lvgl/examples/widgets/table/: lv_example_table_cells.c lv_example_table_file_browser.c lv_example_table_merge_cells.c lv_example_table_rows_columns.c lv_example_table_scroll.c lv_example_table_scrollable_list.c lv_example_table_styling.c lv_example_table_width.c
    ../../../lvgl/examples/widgets/tabview/: lv_example_tabview_active_tab.c lv_example_tabview_basic.c lv_example_tabview_tab_bar_position.c lv_example_tabview_tab_bar_style.c lv_example_tabview_tab_button_content.c
    ../../../lvgl/examples/widgets/textarea/: lv_example_textarea_buttonmatrix.c lv_example_textarea_cursor.c lv_example_textarea_format.c lv_example_textarea_password.c lv_example_textarea_placeholder.c
    ../../../lvgl/examples/widgets/tileview/: lv_example_tileview_l_shape.c
    ../../../lvgl/examples/widgets/win/: lv_example_win_toolbar.c
