# IAR project lvgl.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M55M1 series Nuvoton M55M1 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: NDEBUG; ARM_MATH_CM55; M55M1=1; LV_CONF_INCLUDE_SIMPLE; __800x480__; NVT_DCACHE_ON=1
  ICCARM.CCDiagSuppress: Pa089,Pa082,Pe236,Pa118,Pe111,Pe188,Pe546,Pe144,Pe177,Pe513,Pe1757,Pe167,Pe191,Pe174,Pe186
  ICCARM.CCIncludePath2: ../../../bsp/m55m1/Library/Device/Nuvoton/M55M1/Include; ../../../bsp\m55m1/Library/CMSIS/Core/Include; ../../../bsp/m55m1/Library/CMSIS/DSP/Include; ../../../bsp/m55m1/Library/CMSIS/Include; ../lv_port/gdma; ../../../bsp/m55m1/Library/StdDriver/inc; ../; ../../../thirdparty/FreeRTOS/include; ../../../thirdparty/FreeRTOS/portable/IAR/ARM_CM55_NTZ/non_secure; ../../../common/drv_disp; ../../../common/drv_indev; ../../../common; ../lv_port; ../../../lvgl/src; ../../../lvgl/src/core; ../../../lvgl/src/draw; ../../../lvgl/src/draw/sw; ../../../lvgl/src/font; ../../../lvgl/src/misc; ../../../lvgl/src/widgets; ../../../lvgl/demos/; ../../../lvgl/demos/benchmark; ../../../lvgl/demos/music; ../../../lvgl/demos/stress; ../../../lvgl/demos/widgets; ../../../lvgl/demos/music/assets; ../../../lvgl/demos/keypad_encoder; ../../../; ../sls_files; ..\..\..\thirdparty\arm2d\Helper\Include; ..\..\..\thirdparty\arm2d\Library\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../
  OBJCOPY.OOCOutputFile: lvgl_m55m1.bin
  ILINK.IlinkOutputFile: lvgl_m55m1.out
  ILINK.IlinkIcfFile: M55M1.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../bsp/m55m1/Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group FreeRTOS
    ../../../thirdparty/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../thirdparty/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../thirdparty/FreeRTOS/portable/IAR/ARM_CM55_NTZ/non_secure/: port.c portasm.s
  group Library
    ../../../bsp/m55m1/Library/StdDriver/src/: clk.c ebi.c gpio.c i2c.c pdma.c retarget.c sys.c uart.c
    ../lv_port/gdma/: dma350_ch_drv.c dma350_drv.c dma350_lib.c
  group lv_draw
    ../../../common/drv_draw/gdma/: drv_gdma.c lv_draw_gdma.c lv_draw_gdma.h lv_draw_gdma_fill.c lv_draw_gdma_image.c lv_draw_gdma_layer.c
  group lv_port
    ../../../common/drv_disp/: disp_lt7381.c lt7381_ebi.c
    ../lv_port/: drv_pdma.c drv_pdma.h lv_glue.c lv_glue.h
    ../../../common/: lv_demo.c lv_port_disp.c lv_port_indev.c nu_misc.c
    ../../../common/drv_indev/: touch_ft5316.c
  group lvgl
    ../../../lvgl/src/misc/cache/: _lv_cache_lru_rb.c lv_cache.c lv_cache_entry.c lv_image_cache.c
    ../../../lvgl/demos/multilang/assets/fonts/: font_multilang_large.c font_multilang_small.c
    ../../../lvgl/demos/benchmark/assets/: img_benchmark_cogwheel_alpha256.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c lv_font_benchmark_montserrat_12_compr_az.c.c lv_font_benchmark_montserrat_16_compr_az.c.c lv_font_benchmark_montserrat_28_compr_az.c.c
    ../../../lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_demo_widgets_needle.c img_lvgl_logo.c
    ../../../lvgl/demos/vector_graphic/assets/: img_demo_vector_avatar.c
    ../../../lvgl/demos/multilang/assets/emojis/: img_emoji_artist_palette.c img_emoji_books.c img_emoji_camera_with_flash.c img_emoji_cat_face.c img_emoji_deciduous_tree.c img_emoji_dog_face.c img_emoji_earth_globe_europe_africa.c img_emoji_flexed_biceps.c img_emoji_movie_camera.c img_emoji_red_heart.c img_emoji_rocket.c img_emoji_soccer_ball.c
    ../../../lvgl/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
    ../../../lvgl/demos/multilang/assets/avatars/: img_multilang_avatar_1.c img_multilang_avatar_10.c img_multilang_avatar_11.c img_multilang_avatar_12.c img_multilang_avatar_13.c img_multilang_avatar_14.c img_multilang_avatar_15.c img_multilang_avatar_16.c img_multilang_avatar_17.c img_multilang_avatar_18.c img_multilang_avatar_19.c img_multilang_avatar_2.c img_multilang_avatar_22.c img_multilang_avatar_25.c img_multilang_avatar_3.c img_multilang_avatar_4.c img_multilang_avatar_5.c img_multilang_avatar_6.c img_multilang_avatar_7.c img_multilang_avatar_8.c img_multilang_avatar_9.c
    ../../../lvgl/demos/multilang/assets/: img_multilang_like.c
    ../../../lvgl/demos/render/assets/: img_render_arc_bg.c img_render_lvgl_logo_argb8888.c img_render_lvgl_logo_rgb565.c img_render_lvgl_logo_rgb888.c img_render_lvgl_logo_xrgb8888.c
    ../../../lvgl/demos/transform/assets/: img_transform_avatar_15.c
    ../../../lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_utils.c
    ../../../lvgl/src/widgets/animimage/: lv_animimage.c
    ../../../lvgl/src/widgets/arc/: lv_arc.c
    ../../../lvgl/src/widgets/bar/: lv_bar.c
    ../../../lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../../../lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../../../lvgl/src/widgets/button/: lv_button.c
    ../../../lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../../../lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../../lvgl/src/widgets/canvas/: lv_canvas.c
    ../../../lvgl/src/widgets/chart/: lv_chart.c
    ../../../lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../../../lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_windows.c
    ../../../lvgl/demos/benchmark/: lv_demo_benchmark.c
    ../../../lvgl/demos/flex_layout/: lv_demo_flex_layout_ctrl_pad.c lv_demo_flex_layout_flex_loader.c lv_demo_flex_layout_main.c lv_demo_flex_layout_view.c lv_demo_flex_layout_view_child_node.c lv_demo_flex_layout_view_ctrl_pad.c
    ../../../lvgl/demos/keypad_encoder/: lv_demo_keypad_encoder.c
    ../../../lvgl/demos/multilang/: lv_demo_multilang.c
    ../../../lvgl/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
    ../../../lvgl/demos/render/: lv_demo_render.c
    ../../../lvgl/demos/scroll/: lv_demo_scroll.c
    ../../../lvgl/demos/stress/: lv_demo_stress.c
    ../../../lvgl/demos/transform/: lv_demo_transform.c
    ../../../lvgl/demos/vector_graphic/: lv_demo_vector_graphic.c
    ../../../lvgl/demos/widgets/: lv_demo_widgets.c
    ../../../lvgl/demos/: lv_demos.c
    ../../../lvgl/src/display/: lv_display.c
    ../../../lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../../../lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_utils.c
    ../../../lvgl/src/draw/sdl/: lv_draw_sdl.c
    ../../../lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c
    ../../../lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb888.c
    ../../../lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../../../lvgl/src/layouts/flex/: lv_flex.c
    ../../../lvgl/src/libs/fsdrv/: lv_fs_fatfs.c
    ../../../lvgl/src/layouts/grid/: lv_grid.c
    ../../../lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
    ../../../lvgl/src/widgets/image/: lv_image.c
    ../../../lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../../../lvgl/src/indev/: lv_indev.c lv_indev_scroll.c
    ../../../lvgl/src/: lv_init.c
    ../../../lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../../../lvgl/src/widgets/label/: lv_label.c
    ../../../lvgl/src/layouts/: lv_layout.c
    ../../../lvgl/src/widgets/led/: lv_led.c
    ../../../lvgl/src/widgets/line/: lv_line.c
    ../../../lvgl/src/widgets/list/: lv_list.c
    ../../../lvgl/src/stdlib/: lv_mem.c
    ../../../lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../../../lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../../../lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../../../lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../../../lvgl/src/widgets/menu/: lv_menu.c
    ../../../lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../../../lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../../../lvgl/src/others/observer/: lv_observer.c
    ../../../lvgl/src/widgets/roller/: lv_roller.c
    ../../../lvgl/src/widgets/scale/: lv_scale.c
    ../../../lvgl/src/widgets/slider/: lv_slider.c
    ../../../lvgl/src/widgets/span/: lv_span.c
    ../../../lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../../../lvgl/src/widgets/spinner/: lv_spinner.c
    ../../../lvgl/src/widgets/switch/: lv_switch.c
    ../../../lvgl/src/others/sysmon/: lv_sysmon.c
    ../../../lvgl/src/widgets/table/: lv_table.c
    ../../../lvgl/src/widgets/tabview/: lv_tabview.c
    ../../../lvgl/src/widgets/textarea/: lv_textarea.c
    ../../../lvgl/src/themes/: lv_theme.c
    ../../../lvgl/src/themes/default/: lv_theme_default.c
    ../../../lvgl/src/themes/mono/: lv_theme_mono.c
    ../../../lvgl/src/themes/simple/: lv_theme_simple.c
    ../../../lvgl/src/tick/: lv_tick.c
    ../../../lvgl/src/widgets/tileview/: lv_tileview.c
    ../../../lvgl/src/widgets/win/: lv_win.c
  group User
    ../: main.c
    ../components/: task_lv.c
