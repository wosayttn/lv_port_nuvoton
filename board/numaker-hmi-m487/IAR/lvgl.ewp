# IAR project lvgl.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M481AE series Nuvoton M480AE series (M481AE,M482AE,M483AE,M484AE,M485AE,M487AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; ARM_MATH_CM4; M487JI=1; LV_CONF_INCLUDE_SIMPLE; __320x240__; __FPU_PRESENT=1
  ICCARM.CCDiagSuppress: Pa089,Pa082,Pe236,Pa118,Pe111,Pe188,Pe546
  ICCARM.CCIncludePath2: ../../../bsp/m480/Library/Device/Nuvoton/M480/Include; ../../../bsp/m480/Library/CMSIS/Include; ../../../bsp/m480/Library/StdDriver/inc; ../; ../lv_port; ../../../lvgl/; ../../../lvgl/src/core; ../../../lvgl/src/draw; ../../../lvgl/src/extra; ../../../lvgl/src/font; ../../../lvgl/src/hal; ../../../lvgl/src/misc; ../../../lvgl/src/widgets; ../../../lvgl/src/draw/arm2d; ../../../lvgl/src/draw/renesas; ../../../lvgl/src/draw/sdl; ../../../lvgl/src/draw/stm32_dma2d; ../../../lvgl/src/draw/sw; ../../../lvgl/src/draw/swm341_dma2d; ../../../lvgl/src/draw/nxp\pxp; ../../../lvgl/src/draw/nxp\vglite; ../../../lvgl/src/extra/layouts; ../../../lvgl/src/extra/libs; ../../../lvgl/src/extra/others; ../../../lvgl/src/extra/themes; ../../../lvgl/src/extra/widgets; ../../../lvgl/src/extra/layouts/flex; ../../../lvgl/src/extra/layouts/grid; ../../../lvgl/src/extra/libs/bmp; ../../../lvgl/src/extra/libs/ffmpeg; ../../../lvgl/src/extra/libs/freetype; ../../../lvgl/src/extra/libs/fsdrv; ../../../lvgl/src/extra/libs/gif; ../../../lvgl/src/extra/libs/png; ../../../lvgl/src/extra/libs/qrcode; ../../../lvgl/src/extra/libs/rlottie; ../../../lvgl/src/extra/libs/sjpg; ../../../lvgl/src/extra/others/fragment; ../../../lvgl/src/extra/others/gridnav; ../../../lvgl/src/extra/others/ime; ../../../lvgl/src/extra/others/imgfont; ../../../lvgl/src/extra/others/monkey; ../../../lvgl/src/extra/others/msg; ../../../lvgl/src/extra/others/snapshot; ../../../lvgl/src/extra/themes/basic; ../../../lvgl/src/extra/themes/default; ../../../lvgl/src/extra/themes/mono; ../../../lvgl/src/extra/widgets/animimg; ../../../lvgl/src/extra/widgets/calendar; ../../../lvgl/src/extra/widgets/chart; ../../../lvgl/src/extra/widgets/colorwheel; ../../../lvgl/src/extra/widgets/imgbtn; ../../../lvgl/src/extra/widgets/keyboard; ../../../lvgl/src/extra/widgets/led; ../../../lvgl/src/extra/widgets/list; ../../../lvgl/src/extra/widgets/menu; ../../../lvgl/src/extra/widgets/meter; ../../../lvgl/src/extra/widgets/msgbox; ../../../lvgl/src/extra/widgets/span; ../../../lvgl/src/extra/widgets/spinbox; ../../../lvgl/src/extra/widgets/spinner; ../../../lvgl/src/extra/widgets/tabview; ../../../lvgl/src/extra/widgets/tileview; ../../../lvgl/src/extra/widgets/win; ../../../lvgl/demos/benchmark; ../../../lvgl/demos/keypad_encoder; ../../../lvgl/demos/music; ../../../lvgl/demos/stress; ../../../lvgl/demos/widgets; ../../../lvgl/demos/music/assets; ../../../; ../sls_files; ../../../common; ../../../common/drv_disp; ../../../common/drv_indev
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: lvgl_m480.bin
  ILINK.IlinkOutputFile: lvgl_m480.out
  ILINK.IlinkIcfFile: M487JI.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../bsp/m480/Library/Device/Nuvoton/M480/Source/IAR/: startup_M480.s
    ../../../bsp/m480/Library/Device/Nuvoton/M480/Source/: system_M480.c
  group Library
    ../../../bsp/m480/Library/StdDriver/src/: clk.c eadc.c ebi.c gpio.c pdma.c retarget.c sys.c uart.c
  group lv_port
    ../../../common/drv_disp/: disp_ili9341.c ili9341_ebi.c
    ../lv_port/: drv_pdma.c drv_pdma.h lv_demo.c lv_glue.c lv_glue.h lv_port_disp.c lv_port_indev.c
    ../../../common/: nu_misc.c
    ../../../common/drv_indev/: touch_adc.c touch_adc_calibration.c
  group lvgl
    ../../../lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../../lvgl/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c img_benchmark_cogwheel_rgb565a8.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
    ../../../lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
    ../../../lvgl/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
    ../../../lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../../../lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../../../lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../../../lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../../../lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../../lvgl/src/extra/widgets/chart/: lv_chart.c
    ../../../lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../../lvgl/demos/benchmark/: lv_demo_benchmark.c
    ../../../lvgl/demos/keypad_encoder/: lv_demo_keypad_encoder.c
    ../../../lvgl/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
    ../../../lvgl/demos/stress/: lv_demo_stress.c
    ../../../lvgl/demos/widgets/: lv_demo_widgets.c
    ../../../lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../../../lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../../lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../../../lvgl/src/extra/: lv_extra.c
    ../../../lvgl/src/extra/layouts/flex/: lv_flex.c
    ../../../lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../../../lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../../lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../../../lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_stdio.c
    ../../../lvgl/src/extra/layouts/grid/: lv_grid.c
    ../../../lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../../../lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../../lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../../../lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../../lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../../../lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../../lvgl/src/extra/widgets/led/: lv_led.c
    ../../../lvgl/src/extra/widgets/list/: lv_list.c
    ../../../lvgl/src/extra/widgets/menu/: lv_menu.c
    ../../../lvgl/src/extra/widgets/meter/: lv_meter.c
    ../../../lvgl/src/extra/others/monkey/: lv_monkey.c
    ../../../lvgl/src/extra/others/msg/: lv_msg.c
    ../../../lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../../lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../../../lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../../lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../../../lvgl/src/extra/widgets/span/: lv_span.c
    ../../../lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../../lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../../../lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../../../lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../../../lvgl/src/extra/themes/default/: lv_theme_default.c
    ../../../lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../../../lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../../../lvgl/src/extra/widgets/win/: lv_win.c
  group User
    ../: main.c
