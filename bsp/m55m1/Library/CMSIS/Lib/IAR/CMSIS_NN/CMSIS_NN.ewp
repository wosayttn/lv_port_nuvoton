# IAR project CMSIS_NN.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 61
  General.FPU2: 7
  ICCARM.CCDefines: ARM_MATH_DSP; ARM_MATH_LOOPUNROLL; ARM_MATH_HELIUM
  ICCARM.CCIncludePath2: ..\..\..\..\Core\Include; ..\..\..\..\NN\Include; ..\..\..\..\DSP\Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: CMSIS-NN.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group ActivationFunctions
    ../../../NN/Source/ActivationFunctions/: arm_nn_activations_q15.c arm_nn_activations_q7.c arm_relu6_s8.c arm_relu_q15.c arm_relu_q7.c
  group BasicMathFunctions
    ../../../NN/Source/BasicMathFunctions/: arm_elementwise_add_s16.c arm_elementwise_add_s8.c arm_elementwise_mul_s16.c arm_elementwise_mul_s8.c
  group ConcatenationFunctions
    ../../../NN/Source/ConcatenationFunctions/: arm_concatenation_s8_w.c arm_concatenation_s8_x.c arm_concatenation_s8_y.c arm_concatenation_s8_z.c
  group ConvolutionFunctions
    ../../../NN/Source/ConvolutionFunctions/: arm_convolve_1_x_n_s8.c arm_convolve_1x1_HWC_q7_fast_nonsquare.c arm_convolve_1x1_s8_fast.c arm_convolve_fast_s16.c arm_convolve_HWC_q15_basic.c arm_convolve_HWC_q15_fast.c arm_convolve_HWC_q15_fast_nonsquare.c arm_convolve_HWC_q7_basic.c arm_convolve_HWC_q7_basic_nonsquare.c arm_convolve_HWC_q7_fast.c arm_convolve_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q7_RGB.c arm_convolve_s16.c arm_convolve_s8.c arm_convolve_wrapper_s16.c arm_convolve_wrapper_s8.c arm_depthwise_conv_3x3_s8.c arm_depthwise_conv_s16.c arm_depthwise_conv_s8.c arm_depthwise_conv_s8_opt.c arm_depthwise_conv_u8_basic_ver1.c arm_depthwise_conv_wrapper_s8.c arm_depthwise_separable_conv_HWC_q7.c arm_depthwise_separable_conv_HWC_q7_nonsquare.c arm_nn_depthwise_conv_s8_core.c arm_nn_mat_mult_kernel_q7_q15.c arm_nn_mat_mult_kernel_q7_q15_reordered.c arm_nn_mat_mult_kernel_s8_s16.c arm_nn_mat_mult_s8.c
  group FullyConnectedFunctions
    ../../../NN/Source/FullyConnectedFunctions/: arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_q15.c arm_fully_connected_q15_opt.c arm_fully_connected_q7.c arm_fully_connected_q7_opt.c arm_fully_connected_s16.c arm_fully_connected_s8.c
  group NNSupportFunctions
    ../../../NN/Source/NNSupportFunctions/: arm_nn_accumulate_q7_to_q15.c arm_nn_add_q7.c arm_nn_depthwise_conv_nt_t_padded_s8.c arm_nn_depthwise_conv_nt_t_s8.c arm_nn_mat_mul_core_1x_s8.c arm_nn_mat_mul_core_4x_s8.c arm_nn_mat_mul_kernel_s16.c arm_nn_mat_mult_nt_t_s8.c arm_nn_mult_q15.c arm_nn_mult_q7.c arm_nn_vec_mat_mult_t_s16.c arm_nn_vec_mat_mult_t_s8.c arm_nn_vec_mat_mult_t_svdf_s8.c arm_nntables.c arm_q7_to_q15_no_shift.c arm_q7_to_q15_reordered_no_shift.c arm_q7_to_q15_reordered_with_offset.c arm_q7_to_q15_with_offset.c
  group PoolingFunctions
    ../../../NN/Source/PoolingFunctions/: arm_avgpool_s16.c arm_avgpool_s8.c arm_max_pool_s16.c arm_max_pool_s8.c arm_pool_q7_HWC.c
  group ReshapeFunctions
    ../../../NN/Source/ReshapeFunctions/: arm_reshape_s8.c
  group SoftmaxFunctions
    ../../../NN/Source/SoftmaxFunctions/: arm_nn_softmax_common_s8.c arm_softmax_q15.c arm_softmax_q7.c arm_softmax_s16.c arm_softmax_s8.c arm_softmax_s8_s16.c arm_softmax_u8.c arm_softmax_with_batch_q7.c
  group SVDFunctions
    ../../../NN/Source/SVDFunctions/: arm_svdf_s8.c
